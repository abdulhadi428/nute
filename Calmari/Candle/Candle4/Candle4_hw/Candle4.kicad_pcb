# Repository abdulhadi428/nute (continued)

## KiCad design HandyDevices/MotorControl/MotorControl3_hw/MotorCtrl3.kicad_pcb

Schematic: MotorCtrl3.sch, Motor Control v.3

Parts:
BZ1: BUZZER
C1, C91, C92, C94, C95, C96, C97: 10n; CAP_0603
C2, C3, C4, C5, C9, C10, C11, C14, C17, C21, C25, C26, C27, C28, C31, C32, C44, C45, C46, C47, C48, C49, C86, C90, C98: 0.1u; CAP_0603
C6, C7, C8, C20, C87: 4u7; CAP_0603
C12, C16, C88: 1n; CAP_0603
C13, C18: 27pF; CAP_0603
C15, C19, C22, C89: 1u; CAP_0603
C23, C24: 2.2u; CAP_0603
C29, C30, C33, C38, C39, C40, C41, C42, C43, C50, C51, C52: 100p; CAP_0603
C34, C53, C55, C57: 10u; CAP_0805
C35, C54, C56, C58: 4u7/63v
C36, C63, C65, C67: 220n/16v; CAP_0603
C37, C64, C66, C68: 10n/50v; CAP_1206
C59, C60, C61, C62, C70, C71, C72, C73, C74, C75, C76, C77, C78, C79, C80, C81: 0.1u/50v; CAP_0603
C69, C82, C83, C84: 100u/63v
C85: 4u7; CAP_0805
C93: 0.1u
D1, D2, D3, D4, D5, D6, D8, D9: LED
D7, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: 1N4148
DA1, DA5: TLV700XX
DA2: LD1117
DA3, DA4: NCP583SQ
DA6: LM4041
DA7: LMV358
DD1: STM32F407VX-100
DD2: M24C04; SO8E
F1: FUSE0R
HOLE1, HOLE2, HOLE3, HOLE4, HOLE5, HOLE6, HOLE7, HOLE8, HOLE9, HOLE10, HOLE11, HOLE12, HOLE13, HOLE14: HOLE_METALLED
L1: 10uH; IND_0805
Q1: USBLC6_2XX
Q2, Q4, Q6, Q8: MMBT2222
Q3, Q5, Q7: IRLML9303
Q9, Q10, Q11, Q12: BC817
Q13, Q14: IRF7425
R1: 512K; RES_0603
R2, R5: 22R; RES_0603
R3: 510; RES_0603
R4, R8, R14, R42, R45, R46, R57, R58: 10k; RES_0603
R6, R11, R12, R19, R20, R21, R22, R23, R24: 510R; RES_0603
R7: 10K; RES_0603
R9, R10, R13, R15, R43, R47, R48, R51, R52, R60, R62: 1k; RES_0603
R16, R17, R18, R25, R26, R27, R28, R29, R30, R31, R32, R33: 39K; RES_0603
R34, R36, R38, R40: 33k; RES_0603
R35, R37, R39, R41: 4k7; RES_0603
R44: 2k; RES_0603
R49, R50: 4k7
R53, R54: 5R1; RES_0603
R55, R56: 100k; RES_0603
R59, R61: 47k; RES_0603
R63, R64: 2k7; RES_0603
SW1: BUTTON
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25: TESTPOINT
U1, U2, U3, U4: L6470
XL1: USB_B
XL2, XL10, XL11, XL12, XL13: CONN_4X2
XL3: CONN_NOKIA_LCD24
XL4: CONN_3
XL5: ST_SWD
XL6, XL7, XL8, XL9, XL14, XL17, XL19: CONN_2
XL15: CONN_5
XL16, XL18: CONN_8
XL20: CONN_6
XL21, XL23, XL24, XL25, XL26: CONN_4
XL22: CONN_MICROSD
XTAL1: 8MHz; CRYSTAL

Connections:
+3.3V: C2.1, C3.1, C6.1, C9.1, C10.1, C11.1, C12.1, C14.1, C15.1, C17.1, C20.1, C26.1, C90.1, C93.1, DA1.5, DA3.3 (Vout), DD1.6, DD1.11, DD1.19, DD1.28, DD1.50, DD1.75, DD1.100, DD2.8 (Vcc), R6.1, R8.1, R49.1, R50.2, XL3.3 (VDDI), XL3.7 (PAR/~SPI), XL3.22 (Vdd), XL5.1 (Vdd), XL16.3, XL22.4 (VDD)
+5V: BZ1.2, C4.1, C7.1, C16.1, C19.1, C85.1, C86.1, C87.1, DA1.1, DA1.3, DA2.2 (OUT), DA2.PAD (OUT), DA3.1 (EN), DA3.4 (Vin), DA4.1 (EN), DA4.4 (Vin), DA5.1, DA5.3, F1.2, R9.2, XL10.3, XL10.4, XL11.3, XL11.4, XL12.3, XL12.4, XL13.3, XL13.4
+12V: C5.1, C8.1, C36.2, C59.1, C60.1, C61.1, C62.1, C63.2, C65.2, C67.2, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, C79.1, C80.1, C81.1, C82.1, C83.1, C84.1, D10.A, D14.A, D15.A, D16.A, D17.A, D18.A, DA2.3 (IN), Q3.2 (S), Q5.2 (S), Q7.2 (S), Q11.3 (C), Q12.3 (C), Q13.1, Q13.2, Q13.3, Q14.1, Q14.2, Q14.3, R4.1, R14.1, R34.1, R36.1, R38.1, R40.1, R42.1, R55.1, R56.1, U1.2 (VSA), U1.12 (VSB), U1.16 (VSB), U1.26 (VSA), U2.2 (VSA), U2.12 (VSB), U2.16 (VSB), U2.26 (VSA), U3.2 (VSA), U3.12 (VSB), U3.16 (VSB), U3.26 (VSA), U4.2 (VSA), U4.12 (VSB), U4.16 (VSB), U4.26 (VSA), XL2.1, XL2.3, XL2.5, XL2.7, XL6.1, XL7.1, XL8.1, XL16.1, XL16.2
/ADC_1: R38.2, R39.1, U3.5 (ADC_IN)
/ADC_2: R40.2, R41.1, U4.5 (ADC_IN)
/ADC_3: R36.2, R37.1, U2.5 (ADC_IN)
/ADC_4: R34.2, R35.1, U1.5 (ADC_IN)
/BED_ADC: C96.2, DA7.1, DD1.16, R63.2
/BED_HEATER: DD1.54, R47.1
/BED_HEATER_OUT: Q13.5, Q13.6, Q13.7, Q13.8, XL20.1, XL20.2
/BED_R: C94.2, DA7.3, R57.2, XL20.3
/BOOT_CFG: DD1.94, R5.1
/BUSY/SYNC_1: C39.1, D8.C, DD1.81, R26.2, TP2.1, U3.22 (BUSY\SYNC)
/BUSY/SYNC_2: C40.1, D9.C, DD1.85, R27.2, TP5.1, U4.22 (BUSY\SYNC)
/BUSY/SYNC_3: C38.1, D6.C, DD1.88, R25.2, TP8.1, U2.22 (BUSY\SYNC)
/BUSY/SYNC_4: C29.1, D2.C, DD1.57, R16.2, TP11.1, U1.22 (BUSY\SYNC)
/BUTTON: DD1.29, XL15.4
/Buzzer: DD1.63, R10.2
/BuzzerOut: BZ1.1, Q2.3 (C)
/DBG_UART_RX: DD1.93, XL4.3
/DBG_UART_TX: DD1.92, XL4.2 (PM)
/ENCODER1: DD1.25, XL15.2
/ENCODER2: DD1.26, XL15.3
/FLAG_1: C42.1, D4.C, DD1.84, R29.2, TP4.1, U3.24 (FLAG)
/FLAG_2: C43.1, D5.C, DD1.87, R30.2, TP7.1, U4.24 (FLAG)
/FLAG_3: C41.1, D3.C, DD1.56, R28.2, TP10.1, U2.24 (FLAG)
/FLAG_4: C30.1, D1.C, DD1.59, R17.2, TP13.1, U1.24 (FLAG)
/Fan: DD1.47, R13.2
/Fan_Out: Q3.3 (D), XL9.1
/GPIO1: DD1.37, XL18.1
/GPIO2: DD1.89, XL18.2
/GPIO3: DD1.91, XL18.3
/GPIO4: DD1.48, XL18.4
/GPIO5: DD1.51, XL18.5
/GPIO6: DD1.52, XL18.6
/GPIO7: DD1.69, XL18.7
/HEAD_ADC: C97.2, DA7.7, DD1.15, R64.2
/HEAD_HEATER: DD1.53, R48.1
/HEAD_HEATER_OUT: Q14.5, Q14.6, Q14.7, Q14.8, XL21.1
/HEAD_R: C95.2, DA7.5, R58.2, XL21.2 (PM)
/I2C_SCL: DD1.95, DD2.6 (SCL), R49.2, XL16.4
/I2C_SDA: DD1.96, DD2.5 (SDA), R50.1, XL16.5
/LCD_BCKLT: DD1.23, R2.2
/LCD_DA0: DD1.97, XL3.6 ((SDA)DA0)
/LCD_DA1: DD1.98, XL3.18 (DA1)
/LCD_DA2: DD1.1, XL3.8 (DA2)
/LCD_DA3: DD1.2, XL3.17 (DA3)
/LCD_DA4: DD1.3, XL3.9 (DA4)
/LCD_DA5: DD1.4, XL3.15 (DA5)
/LCD_DA6: DD1.5, XL3.10 (DA6)
/LCD_DA7: DD1.38, XL3.14 (DA7)
/LCD_DC: DD1.39, XL3.19 ((SCLK)D/~C)
/LCD_EFF: DD1.44, XL3.13 (TearingEff)
/LCD_RD: DD1.41, XL3.20 (~RD)
/LCD_WR: DD1.40, XL3.5 (~WR)
/LCD_XCS: DD1.42, XL3.11 (CS)
/LCD_XRES: DD1.43, XL3.12 (ResX)
/LIMITER1: DD1.17, XL10.5
/LIMITER2: DD1.64, XL10.6
/LIMITER3: DD1.18, XL11.5
/LIMITER4: DD1.77, XL11.6
/LIMITER5: DD1.33, XL12.5
/LIMITER6: DD1.60, XL12.6
/LIMITER7: DD1.34, XL13.5
/LIMITER8: DD1.62, XL13.6
/MOTOR_CS: DD1.67, TP22.1, U1.23 (CS), U2.23 (CS), U3.23 (CS), U4.23 (CS)
/MOTOR_MISO: DD1.31, TP25.1, U1.18 (SDO)
/MOTOR_MOSI: DD1.32, TP24.1, U3.20 (SDI)
/MOTOR_SCK: DD1.30, TP23.1, U1.19 (CK), U2.19 (CK), U3.19 (CK), U4.19 (CK)
/OUT1_1A: U3.1 (OUT1A), XL24.1
/OUT1_1B: U3.14 (OUT1B), XL24.3
/OUT1_2A: U3.28 (OUT2A), XL24.2 (PM)
/OUT1_2B: U3.15 (OUT2B), XL24.4
/OUT2_1A: U4.1 (OUT1A), XL26.1
/OUT2_1B: U4.14 (OUT1B), XL26.3
/OUT2_2A: U4.28 (OUT2A), XL26.2 (PM)
/OUT2_2B: U4.15 (OUT2B), XL26.4
/OUT3_1A: U2.1 (OUT1A), XL23.1
/OUT3_1B: U2.14 (OUT1B), XL23.3
/OUT3_2A: U2.28 (OUT2A), XL23.2 (PM)
/OUT3_2B: U2.15 (OUT2B), XL23.4
/OUT4_1A: U1.1 (OUT1A), XL25.1
/OUT4_1B: U1.14 (OUT1B), XL25.3
/OUT4_2A: U1.28 (OUT2A), XL25.2 (PM)
/OUT4_2B: U1.15 (OUT2B), XL25.4
/SDI_2: TP18.1, U3.18 (SDO), U4.20 (SDI)
/SDI_3: TP19.1, U2.20 (SDI), U4.18 (SDO)
/SDI_4: TP20.1, U1.20 (SDI), U2.18 (SDO)
/SD_CLK: DD1.80, XL22.5 (SCK/CLK)
/SD_CMD: DD1.83, XL22.3 (MOSI/CMD)
/SD_DAT0: DD1.65, XL22.7 (MISO/DAT0)
/SD_DAT1: DD1.66, XL22.8 (DAT1)
/SD_DAT2: DD1.78, XL22.1 (DAT2)
/SD_DAT3: DD1.79, XL22.2 (~SS~/DAT3)
/STBY/RST: C28.1, C33.1, C50.1, C51.1, C52.1, DD1.14, R8.2, R18.2, R31.2, R32.2, R33.2, TP21.1, U1.3 (STBY\RST), U2.3 (STBY\RST), U3.3 (STBY\RST), U4.3 (STBY\RST), XL19.1
/STEP_CLK_1: DD1.45, TP14.1, U3.25 (STCK)
/STEP_CLK_2: DD1.24, TP15.1, U4.25 (STCK)
/STEP_CLK_3: DD1.90, TP16.1, U2.25 (STCK)
/STEP_CLK_4: DD1.61, TP17.1, U1.25 (STCK)
/SWCLK: DD1.76, XL5.2 (SWCLK)
/SWDIO: DD1.72, XL5.4 (SWDIO)
/SW_1: DD1.82, TP3.1, U3.4 (SW)
/SW_2: DD1.86, TP6.1, U4.4 (SW)
/SW_3: DD1.55, TP9.1, U2.4 (SW)
/SW_4: DD1.58, TP12.1, U1.4 (SW)
/URef: C25.1, DA6.2 (C), DD1.21, R44.2, R45.1, TP1.1
/USB_DM: DD1.70, Q1.6 (I/O1)
/USB_DP: DD1.71, Q1.4 (I/O2)
/Vac1_Out: Q5.3 (D), XL14.1
/Vac2_Out: Q7.3 (D), XL17.1
/Vacuum1: DD1.35, R15.2
/Vacuum2: DD1.36, R43.2
/Vdd1: C46.1, C47.1, C55.1, C56.1, R20.1, R23.1, R26.1, R29.1, R32.1, U3.6 (VREG), U3.17 (VDD)
/Vdd2: C48.1, C49.1, C57.1, C58.1, R21.1, R24.1, R27.1, R30.1, R33.1, U4.6 (VREG), U4.17 (VDD)
/Vdd3: C44.1, C45.1, C53.1, C54.1, R19.1, R22.1, R25.1, R28.1, R31.1, U2.6 (VREG), U2.17 (VDD)
/Vdd4: C31.1, C32.1, C34.1, C35.1, R11.1, R12.1, R16.1, R17.1, R18.1, U1.6 (VREG), U1.17 (VDD)
AGND: C88.2, C89.2, C94.1, C95.1, C98.2, DA5.2, DA6.3 (A), DA7.4, L1.1, R46.2, R60.2, R62.2, XL20.4, XL21.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.1, C25.2, C26.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C90.2, C93.2, DA1.2, DA2.1 (GND), DA3.2 (GND), DA4.2 (GND), DD1.10, DD1.20, DD1.27, DD1.74, DD2.1 (A0), DD2.2 (A1), DD2.3 (A2), DD2.4 (GND), DD2.7 (WP), HOLE1.Hle, HOLE2.Hle, HOLE3.Hle, HOLE4.Hle, HOLE5.Hle, HOLE6.Hle, HOLE7.Hle, HOLE8.Hle, HOLE9.Hle, HOLE10.Hle, HOLE11.Hle, HOLE12.Hle, HOLE13.Hle, HOLE14.Hle, L1.2, Q1.2 (GND), Q2.2 (E), Q4.2 (E), Q6.2 (E), Q8.2 (E), Q9.2 (E), Q10.2 (E), R1.2, R7.2, R35.2, R37.2, R39.2, R41.2, U1.9 (AGND), U1.13 (PGND), U1.21 (DGND), U1.27 (PGND), U1.PAD, U2.9 (AGND), U2.13 (PGND), U2.21 (DGND), U2.27 (PGND), U2.PAD, U3.9 (AGND), U3.13 (PGND), U3.21 (DGND), U3.27 (PGND), U3.PAD, U4.9 (AGND), U4.13 (PGND), U4.21 (DGND), U4.27 (PGND), U4.PAD, XL1.4 (UGND), XL2.2, XL2.4, XL2.6, XL2.8, XL3.1 (GND), XL3.2 (LED-), XL3.4 (GND), XL3.16 (GND), XL3.21 (GND), XL3.24 (GND), XL3.H (Case), XL4.1, XL5.3 (GND), XL6.2 (PM), XL7.2 (PM), XL8.2 (PM), XL9.2 (PM), XL10.7, XL10.8, XL11.7, XL11.8, XL12.7, XL12.8, XL13.7, XL13.8, XL14.2 (PM), XL15.1, XL15.5, XL16.6, XL16.7, XL16.8, XL17.2 (PM), XL18.8, XL19.2 (PM), XL20.5, XL20.6, XL21.4, XL22.6 (GND), XL22.H (Housing), XTAL1.H
unnamed: Q1.1 (I/O1), XL1.2 (D-)
unnamed: Q1.3 (I/O2), XL1.3 (D+)
unnamed: R2.1, XL3.23 (LED+)
unnamed: Q2.1 (B), R10.1
unnamed: C37.2, U1.10 (CP)
unnamed: C37.1, D7.A, D10.C
unnamed: C36.1, D7.C, U1.11 (VBOOT)
unnamed: D1.A, R11.2
unnamed: D2.A, R12.2
unnamed: C97.1, DA7.6, R61.2, R62.1, R64.1
unnamed: DA6.1 (FB), R45.2, R46.1
unnamed: C96.1, DA7.2, R59.2, R60.1, R63.1
unnamed: Q5.1 (G), Q6.3 (C), R14.2
unnamed: Q6.1 (B), R15.1
unnamed: Q4.1 (B), R13.1
unnamed: Q8.1 (B), R43.1
unnamed: Q7.1 (G), Q8.3 (C), R42.2
unnamed: Q3.1 (G), Q4.3 (C), R4.2
unnamed: D20.C, Q10.3 (C), Q12.1 (B), R52.2
unnamed: Q10.1 (B), R48.2
unnamed: C92.1, R54.2
unnamed: C92.2, D20.A, Q12.2 (E), Q14.4, R56.2
unnamed: D18.C, R52.1, R54.1
unnamed: D19.C, Q9.3 (C), Q11.1 (B), R51.2
unnamed: Q9.1 (B), R47.2
unnamed: C91.1, R53.2
unnamed: C91.2, D19.A, Q11.2 (E), Q13.4, R55.2
unnamed: D17.C, R51.1, R53.1
unnamed: C63.1, D11.C, U2.11 (VBOOT)
unnamed: C64.1, D11.A, D14.C
unnamed: D3.A, R19.2
unnamed: D5.A, R21.2
unnamed: D9.A, R24.2
unnamed: D6.A, R22.2
unnamed: C64.2, U2.10 (CP)
unnamed: C13.1, DD1.12, XTAL1.1
unnamed: C18.1, R3.1, XTAL1.2
unnamed: C27.2, R5.2, R7.1, SW1.1
unnamed: C67.1, D13.C, U4.11 (VBOOT)
unnamed: D4.A, R20.2
unnamed: D8.A, R23.2
unnamed: C68.2, U4.10 (CP)
unnamed: C66.1, D12.A, D15.C
unnamed: C66.2, U3.10 (CP)
unnamed: C65.1, D12.C, U3.11 (VBOOT)
unnamed: C68.1, D13.A, D16.C
unnamed: DD1.68, R9.1
unnamed: C23.2, DD1.49
unnamed: DD1.13, R3.2
unnamed: C24.2, DD1.73
unnamed: C27.1, R6.2, SW1.2
unnamed: C1.1, R1.1, XL1.H
unnamed: F1.1, Q1.5 (VBus), XL1.1 (UVcc)
VAA: C21.1, C22.1, C88.1, C89.1, C98.1, DA4.3 (Vout), DA5.5, DA7.8, DD1.22, R44.1, R57.1, R58.1, R59.1, R61.1

Notes on the sheet:
USB detect
MOTOR DRIVER ICs
LCD
CPU
UART1 - debug output SPI1 - Motor Daisy Chain TIM1 Ch4 - STEP CLK 1 TIM2 Ch2 - STEP CLK 2 TIM3 Ch1 - STEP CLK 3 TIM4 Ch3 - STEP CLK 4 TIM5 Ch1 - LCD Bcklt TIM8 Ch1 - Buzzer TIM12 Ch1 - Head Heater TIM12 Ch2 - Bed Heater ADC10 - Head ADC ADC11 - Bed ADC
Radiator holes
Limiters
Buzzer
SD card
I2C pull-ups
I2C Addr = 1010 (A2)(A1)(A0) in case of 1 or 2 kBit, I2C Addr = 1010 (A2)(A1) in case of 4 kBit. A2, A1, A0 are read as 0 when left floating
Encoder & button
+12V Power Input & Outputs
Uncontrolled Fans
Controlled Fan
Vacuum1
Vacuum2
Heaters
Choose one or another
VAA GND filter
Reference voltage 2466mV
Temperature measurement amplifiers
Digital power
Analog power
SWD Programming
Debug UART
Feeders
GPIOs
Bootloader
Reset
USB
Power input

Board: 2 copper layers, 279 parts (0 on the bottom side), 172 nets, no tracks yet.
